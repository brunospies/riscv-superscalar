

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO RISCV_superscalar 
  PIN clock 
    ANTENNAPARTIALMETALAREA 252.555 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 779.451 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 14.4375 LAYER MET3 ; 
    ANTENNAMAXAREACAR 21.6388 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 62.9062 LAYER MET3 ;
  END clock
  PIN reset 
    ANTENNAPARTIALMETALAREA 1449.68 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 4507.71 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 142.459 LAYER MET3 ; 
    ANTENNAMAXAREACAR 13.5082 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 39.2813 LAYER MET3 ;
  END reset
  PIN instruction[63] 
    ANTENNAPARTIALMETALAREA 125.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 394.42 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 302 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 927.611 LAYER MET3 ;
  END instruction[63]
  PIN instruction[62] 
    ANTENNAPARTIALMETALAREA 160.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 508.565 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 357.593 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1128.49 LAYER MET3 ;
  END instruction[62]
  PIN instruction[61] 
    ANTENNAPARTIALMETALAREA 113.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 350.39 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 280.06 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 860.13 LAYER MET3 ;
  END instruction[61]
  PIN instruction[60] 
    ANTENNAPARTIALMETALAREA 125.56 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 390.72 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 300.736 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 914.078 LAYER MET3 ;
  END instruction[60]
  PIN instruction[59] 
    ANTENNAPARTIALMETALAREA 124.66 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 390.535 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 301.417 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 942.456 LAYER MET3 ;
  END instruction[59]
  PIN instruction[58] 
    ANTENNAPARTIALMETALAREA 274.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 853.775 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 612.165 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1898.59 LAYER MET3 ;
  END instruction[58]
  PIN instruction[57] 
    ANTENNAPARTIALMETALAREA 110.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 343.545 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 252.56 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 778.045 LAYER MET3 ;
  END instruction[57]
  PIN instruction[56] 
    ANTENNAPARTIALMETALAREA 7.5 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.808 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 211.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 660.45 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 496.692 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1523.77 LAYER MET3 ;
  END instruction[56]
  PIN instruction[55] 
    ANTENNAPARTIALMETALAREA 19.98 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 42.432 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 162.6 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 506.53 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 592.253 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1618.15 LAYER MET3 ;
  END instruction[55]
  PIN instruction[54] 
    ANTENNAPARTIALMETALAREA 4.38 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.152 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 158.2 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 494.69 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 363.703 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1129.56 LAYER MET3 ;
  END instruction[54]
  PIN instruction[53] 
    ANTENNAPARTIALMETALAREA 22.44 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.68 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 173.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 545.75 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 387.637 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1215.18 LAYER MET3 ;
  END instruction[53]
  PIN instruction[52] 
    ANTENNAPARTIALMETALAREA 133.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 420.135 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 300.253 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 938.216 LAYER MET3 ;
  END instruction[52]
  PIN instruction[51] 
    ANTENNAPARTIALMETALAREA 19.28 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.536 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 86.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 274.91 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 193.593 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 614.962 LAYER MET3 ;
  END instruction[51]
  PIN instruction[50] 
    ANTENNAPARTIALMETALAREA 8.17 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.92 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 100.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 315.61 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 228.297 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 712.43 LAYER MET3 ;
  END instruction[50]
  PIN instruction[49] 
    ANTENNAPARTIALMETALAREA 22.34 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 48.064 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 84.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 267.14 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 229 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 682.421 LAYER MET3 ;
  END instruction[49]
  PIN instruction[48] 
    ANTENNAPARTIALMETALAREA 3.6 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.488 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 167.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 521.515 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 460.363 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1351.85 LAYER MET3 ;
  END instruction[48]
  PIN instruction[47] 
    ANTENNAPARTIALMETALAREA 24.54 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 53.952 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 50.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 158.73 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 169.527 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 478.197 LAYER MET3 ;
  END instruction[47]
  PIN instruction[46] 
    ANTENNAPARTIALMETALAREA 124.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 396.085 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 281.747 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 889.016 LAYER MET3 ;
  END instruction[46]
  PIN instruction[45] 
    ANTENNAPARTIALMETALAREA 126.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 396.64 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 296.868 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 916.399 LAYER MET3 ;
  END instruction[45]
  PIN instruction[44] 
    ANTENNAPARTIALMETALAREA 134 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 423.65 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 346.25 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1069.3 LAYER MET3 ;
  END instruction[44]
  PIN instruction[43] 
    ANTENNAPARTIALMETALAREA 12.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 123.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 391.83 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 279.901 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 883.322 LAYER MET3 ;
  END instruction[43]
  PIN instruction[42] 
    ANTENNAPARTIALMETALAREA 5.16 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.816 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 227.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 711.695 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 510.626 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1590.82 LAYER MET3 ;
  END instruction[42]
  PIN instruction[41] 
    ANTENNAPARTIALMETALAREA 26.34 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 56 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 105.9 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 336.885 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 238.758 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 756.14 LAYER MET3 ;
  END instruction[41]
  PIN instruction[40] 
    ANTENNAPARTIALMETALAREA 8.28 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.472 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 242.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 758.87 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 585.012 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1824.83 LAYER MET3 ;
  END instruction[40]
  PIN instruction[39] 
    ANTENNAPARTIALMETALAREA 132.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 419.95 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 326.155 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1025.14 LAYER MET3 ;
  END instruction[39]
  PIN instruction[38] 
    ANTENNAPARTIALMETALAREA 145.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 456.21 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 322.736 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1013.42 LAYER MET3 ;
  END instruction[38]
  PIN instruction[37] 
    ANTENNAPARTIALMETALAREA 92.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 290.635 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 244.107 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 745.285 LAYER MET3 ;
  END instruction[37]
  PIN instruction[36] 
    ANTENNAPARTIALMETALAREA 145.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 455.655 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 322.956 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1012.2 LAYER MET3 ;
  END instruction[36]
  PIN instruction[35] 
    ANTENNAPARTIALMETALAREA 173 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 543.9 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 386.011 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1210.23 LAYER MET3 ;
  END instruction[35]
  PIN instruction[34] 
    ANTENNAPARTIALMETALAREA 131.86 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 415.325 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 328.275 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1002.46 LAYER MET3 ;
  END instruction[34]
  PIN instruction[33] 
    ANTENNAPARTIALMETALAREA 188.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 592.185 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 426.187 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1331.26 LAYER MET3 ;
  END instruction[33]
  PIN instruction[32] 
    ANTENNAPARTIALMETALAREA 124.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 390.535 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 276.538 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 869.082 LAYER MET3 ;
  END instruction[32]
  PIN instruction[31] 
    ANTENNAPARTIALMETALAREA 14.52 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 160.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 505.79 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 355.703 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1122.39 LAYER MET3 ;
  END instruction[31]
  PIN instruction[30] 
    ANTENNAPARTIALMETALAREA 12.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 125.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 395.345 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 361.407 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1058.78 LAYER MET3 ;
  END instruction[30]
  PIN instruction[29] 
    ANTENNAPARTIALMETALAREA 13.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.12 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 95.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 304.325 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 229.835 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 714.634 LAYER MET3 ;
  END instruction[29]
  PIN instruction[28] 
    ANTENNAPARTIALMETALAREA 7.64 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.704 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 128.86 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 409.405 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 309.198 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 962.008 LAYER MET3 ;
  END instruction[28]
  PIN instruction[27] 
    ANTENNAPARTIALMETALAREA 12.18 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.792 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 125.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 395.16 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 309.143 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 943.723 LAYER MET3 ;
  END instruction[27]
  PIN instruction[26] 
    ANTENNAPARTIALMETALAREA 13.76 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.76 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 214.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 668.96 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 530.681 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1608 LAYER MET3 ;
  END instruction[26]
  PIN instruction[25] 
    ANTENNAPARTIALMETALAREA 36.42 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 77.504 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 186.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 583.49 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 482.802 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1440.71 LAYER MET3 ;
  END instruction[25]
  PIN instruction[24] 
    ANTENNAPARTIALMETALAREA 33.36 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 70.976 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 100.82 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 319.495 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 271.154 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 810.427 LAYER MET3 ;
  END instruction[24]
  PIN instruction[23] 
    ANTENNAPARTIALMETALAREA 9.08 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.776 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 58.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 183.335 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 186.846 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 547.144 LAYER MET3 ;
  END instruction[23]
  PIN instruction[22] 
    ANTENNAPARTIALMETALAREA 5.94 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.48 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 156.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 487.66 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 377.845 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1173.71 LAYER MET3 ;
  END instruction[22]
  PIN instruction[21] 
    ANTENNAPARTIALMETALAREA 2.82 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.824 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 112.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 354.645 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 332.67 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 995.887 LAYER MET3 ;
  END instruction[21]
  PIN instruction[20] 
    ANTENNAPARTIALMETALAREA 10.62 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.464 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 160.62 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 505.605 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 390.67 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1207.19 LAYER MET3 ;
  END instruction[20]
  PIN instruction[19] 
    ANTENNAPARTIALMETALAREA 12.18 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.792 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 118.02 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 369.075 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 391.396 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1113.44 LAYER MET3 ;
  END instruction[19]
  PIN instruction[18] 
    ANTENNAPARTIALMETALAREA 5.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.12 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 124.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 387.945 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 423.821 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1197.01 LAYER MET3 ;
  END instruction[18]
  PIN instruction[17] 
    ANTENNAPARTIALMETALAREA 30.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.704 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 71.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 229.955 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 253.484 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 725.469 LAYER MET3 ;
  END instruction[17]
  PIN instruction[16] 
    ANTENNAPARTIALMETALAREA 20.78 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 44.736 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 33.84 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 109.52 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 255.583 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 655.449 LAYER MET3 ;
  END instruction[16]
  PIN instruction[15] 
    ANTENNAPARTIALMETALAREA 10.62 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.464 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 75.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 238.28 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 225 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 653.032 LAYER MET3 ;
  END instruction[15]
  PIN instruction[14] 
    ANTENNAPARTIALMETALAREA 45.02 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 96.448 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 196.9 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 616.605 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 492.659 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1504.78 LAYER MET3 ;
  END instruction[14]
  PIN instruction[13] 
    ANTENNAPARTIALMETALAREA 13.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.12 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 151.42 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 478.965 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 369.462 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1134.89 LAYER MET3 ;
  END instruction[13]
  PIN instruction[12] 
    ANTENNAPARTIALMETALAREA 9.06 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.136 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 316.68 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 991.97 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 715.264 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2225.24 LAYER MET3 ;
  END instruction[12]
  PIN instruction[11] 
    ANTENNAPARTIALMETALAREA 32.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 70.72 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 137.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 434.38 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 311.462 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 976.838 LAYER MET3 ;
  END instruction[11]
  PIN instruction[10] 
    ANTENNAPARTIALMETALAREA 37.26 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 79.296 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 178.9 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 561.105 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 425.835 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1313.96 LAYER MET3 ;
  END instruction[10]
  PIN instruction[9] 
    ANTENNAPARTIALMETALAREA 11.4 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.128 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 166.74 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 527.065 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 372.253 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1173.23 LAYER MET3 ;
  END instruction[9]
  PIN instruction[8] 
    ANTENNAPARTIALMETALAREA 21.54 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.76 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 129.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 409.59 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 288.978 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 910.962 LAYER MET3 ;
  END instruction[8]
  PIN instruction[7] 
    ANTENNAPARTIALMETALAREA 11.4 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.128 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 161.46 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 508.195 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 365.791 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1142.73 LAYER MET3 ;
  END instruction[7]
  PIN instruction[6] 
    ANTENNAPARTIALMETALAREA 1.26 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.496 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 123.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 389.24 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 275.088 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 866.236 LAYER MET3 ;
  END instruction[6]
  PIN instruction[5] 
    ANTENNAPARTIALMETALAREA 27.02 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.048 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 80.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 252.34 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 196.121 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 600.733 LAYER MET3 ;
  END instruction[5]
  PIN instruction[4] 
    ANTENNAPARTIALMETALAREA 12.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 193.62 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 612.535 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 429.33 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1356.99 LAYER MET3 ;
  END instruction[4]
  PIN instruction[3] 
    ANTENNAPARTIALMETALAREA 19.22 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.408 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 517.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1625.6 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 1157.57 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 3617.4 LAYER MET3 ;
  END instruction[3]
  PIN instruction[2] 
    ANTENNAPARTIALMETALAREA 5.22 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.944 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 331.68 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1045.99 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 734.978 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2314.61 LAYER MET3 ;
  END instruction[2]
  PIN instruction[1] 
    ANTENNAPARTIALMETALAREA 46.66 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 100.544 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 378.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1189.18 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 835.44 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2624.35 LAYER MET3 ;
  END instruction[1]
  PIN instruction[0] 
    ANTENNAPARTIALMETALAREA 30.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.704 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 242.72 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 757.02 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 537.242 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1674.54 LAYER MET3 ;
  END instruction[0]
  PIN data_i[63] 
    ANTENNAPARTIALMETALAREA 326.5 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1010.28 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 721.374 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2231.17 LAYER MET3 ;
  END data_i[63]
  PIN data_i[62] 
    ANTENNAPARTIALMETALAREA 21.56 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.4 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 297.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 935.73 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 656.626 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2067.31 LAYER MET3 ;
  END data_i[62]
  PIN data_i[61] 
    ANTENNAPARTIALMETALAREA 337.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1045.43 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 746.802 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2313.39 LAYER MET3 ;
  END data_i[61]
  PIN data_i[60] 
    ANTENNAPARTIALMETALAREA 44.24 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 94.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 234.5 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 739.445 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 519.176 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1635.92 LAYER MET3 ;
  END data_i[60]
  PIN data_i[59] 
    ANTENNAPARTIALMETALAREA 35.58 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 75.712 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 302.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 944.795 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 674.67 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2098.63 LAYER MET3 ;
  END data_i[59]
  PIN data_i[58] 
    ANTENNAPARTIALMETALAREA 2.82 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.824 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 214.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 671.365 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 515.791 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1595.61 LAYER MET3 ;
  END data_i[58]
  PIN data_i[57] 
    ANTENNAPARTIALMETALAREA 129.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 401.265 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 381.484 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1111.17 LAYER MET3 ;
  END data_i[57]
  PIN data_i[56] 
    ANTENNAPARTIALMETALAREA 240.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 748.14 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 559.176 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1724.6 LAYER MET3 ;
  END data_i[56]
  PIN data_i[55] 
    ANTENNAPARTIALMETALAREA 3.6 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.488 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 574.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1803.75 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 1266.74 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 3975.05 LAYER MET3 ;
  END data_i[55]
  PIN data_i[54] 
    ANTENNAPARTIALMETALAREA 37.32 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 79.424 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 277.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 862.1 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 654.451 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1994.25 LAYER MET3 ;
  END data_i[54]
  PIN data_i[53] 
    ANTENNAPARTIALMETALAREA 48.24 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 102.72 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 354.38 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1109.07 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 803.89 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2495.19 LAYER MET3 ;
  END data_i[53]
  PIN data_i[52] 
    ANTENNAPARTIALMETALAREA 13.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.12 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 268.46 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 838.975 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 627.736 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1940.02 LAYER MET3 ;
  END data_i[52]
  PIN data_i[51] 
    ANTENNAPARTIALMETALAREA 339.8 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1058.2 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 776.67 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2395.37 LAYER MET3 ;
  END data_i[51]
  PIN data_i[50] 
    ANTENNAPARTIALMETALAREA 294.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 910.94 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 680.121 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2075.7 LAYER MET3 ;
  END data_i[50]
  PIN data_i[49] 
    ANTENNAPARTIALMETALAREA 12.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 180.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 564.62 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 414.099 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1281.37 LAYER MET3 ;
  END data_i[49]
  PIN data_i[48] 
    ANTENNAPARTIALMETALAREA 292.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 907.795 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 677.615 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2071.96 LAYER MET3 ;
  END data_i[48]
  PIN data_i[47] 
    ANTENNAPARTIALMETALAREA 308.62 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 968.105 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 682.077 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2138.47 LAYER MET3 ;
  END data_i[47]
  PIN data_i[46] 
    ANTENNAPARTIALMETALAREA 127.02 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 396.085 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 335.593 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 993.386 LAYER MET3 ;
  END data_i[46]
  PIN data_i[45] 
    ANTENNAPARTIALMETALAREA 234.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 728.9 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 601.143 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1834.52 LAYER MET3 ;
  END data_i[45]
  PIN data_i[44] 
    ANTENNAPARTIALMETALAREA 154.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 478.595 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 360.121 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1101.58 LAYER MET3 ;
  END data_i[44]
  PIN data_i[43] 
    ANTENNAPARTIALMETALAREA 278.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 864.32 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 617.484 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1914.45 LAYER MET3 ;
  END data_i[43]
  PIN data_i[42] 
    ANTENNAPARTIALMETALAREA 386.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1204.35 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 862.407 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2676.39 LAYER MET3 ;
  END data_i[42]
  PIN data_i[41] 
    ANTENNAPARTIALMETALAREA 350.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1089.83 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 773.154 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2406.01 LAYER MET3 ;
  END data_i[41]
  PIN data_i[40] 
    ANTENNAPARTIALMETALAREA 265.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 819.735 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 586.78 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1812.38 LAYER MET3 ;
  END data_i[40]
  PIN data_i[39] 
    ANTENNAPARTIALMETALAREA 117.94 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 367.225 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 270.275 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 833.184 LAYER MET3 ;
  END data_i[39]
  PIN data_i[38] 
    ANTENNAPARTIALMETALAREA 310.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 964.96 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 714.407 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2193.3 LAYER MET3 ;
  END data_i[38]
  PIN data_i[37] 
    ANTENNAPARTIALMETALAREA 346.92 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1074.11 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 766.253 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2371.45 LAYER MET3 ;
  END data_i[37]
  PIN data_i[36] 
    ANTENNAPARTIALMETALAREA 187.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 584.045 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 416.934 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1294.38 LAYER MET3 ;
  END data_i[36]
  PIN data_i[35] 
    ANTENNAPARTIALMETALAREA 250.9 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 774.595 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 580.495 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1772.81 LAYER MET3 ;
  END data_i[35]
  PIN data_i[34] 
    ANTENNAPARTIALMETALAREA 5.94 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.48 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 815.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 2555.59 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 1795.88 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 5627.45 LAYER MET3 ;
  END data_i[34]
  PIN data_i[33] 
    ANTENNAPARTIALMETALAREA 30.12 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.064 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 259.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 817.145 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 574.56 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1806.69 LAYER MET3 ;
  END data_i[33]
  PIN data_i[32] 
    ANTENNAPARTIALMETALAREA 322.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 997.52 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 712.275 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2203.12 LAYER MET3 ;
  END data_i[32]
  PIN data_i[31] 
    ANTENNAPARTIALMETALAREA 130.66 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 409.035 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 294.67 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 917.478 LAYER MET3 ;
  END data_i[31]
  PIN data_i[30] 
    ANTENNAPARTIALMETALAREA 12.96 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 212.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 673.585 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 481.725 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1515.72 LAYER MET3 ;
  END data_i[30]
  PIN data_i[29] 
    ANTENNAPARTIALMETALAREA 143.24 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 444.37 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 351.604 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1069.39 LAYER MET3 ;
  END data_i[29]
  PIN data_i[28] 
    ANTENNAPARTIALMETALAREA 9.06 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.136 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 405.72 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1274.28 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 911.857 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2848.03 LAYER MET3 ;
  END data_i[28]
  PIN data_i[27] 
    ANTENNAPARTIALMETALAREA 12.18 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.792 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 235.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 740.555 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 567.659 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1757.16 LAYER MET3 ;
  END data_i[27]
  PIN data_i[26] 
    ANTENNAPARTIALMETALAREA 34.08 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 72.512 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 294.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 916.12 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 686.978 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2102.84 LAYER MET3 ;
  END data_i[26]
  PIN data_i[25] 
    ANTENNAPARTIALMETALAREA 103.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 323.935 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 230.297 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 722.709 LAYER MET3 ;
  END data_i[25]
  PIN data_i[24] 
    ANTENNAPARTIALMETALAREA 2.04 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.16 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 349.685 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1102.37 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 781.187 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2452.26 LAYER MET3 ;
  END data_i[24]
  PIN data_i[23] 
    ANTENNAPARTIALMETALAREA 23.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 50.368 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 673.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 2114.18 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42 LAYER MET3 ; 
    ANTENNAMAXAREACAR 1609.49 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 5051.1 LAYER MET3 ;
  END data_i[23]
  PIN data_i[22] 
    ANTENNAPARTIALMETALAREA 4.38 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.152 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 346.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1078.18 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 764.934 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2380.39 LAYER MET3 ;
  END data_i[22]
  PIN data_i[21] 
    ANTENNAPARTIALMETALAREA 14.58 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.912 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 218.92 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 689.68 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 502.89 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1564.66 LAYER MET3 ;
  END data_i[21]
  PIN data_i[20] 
    ANTENNAPARTIALMETALAREA 5.94 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.48 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 189.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 598.105 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 427.451 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1341.8 LAYER MET3 ;
  END data_i[20]
  PIN data_i[19] 
    ANTENNAPARTIALMETALAREA 125.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 388.5 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 280.78 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 868.689 LAYER MET3 ;
  END data_i[19]
  PIN data_i[18] 
    ANTENNAPARTIALMETALAREA 94.82 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 297.665 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 250.055 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 745.57 LAYER MET3 ;
  END data_i[18]
  PIN data_i[17] 
    ANTENNAPARTIALMETALAREA 3.6 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.488 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 247.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 773.855 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 578.769 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1787.79 LAYER MET3 ;
  END data_i[17]
  PIN data_i[16] 
    ANTENNAPARTIALMETALAREA 208.3 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 656.195 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 496.44 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1528.12 LAYER MET3 ;
  END data_i[16]
  PIN data_i[15] 
    ANTENNAPARTIALMETALAREA 70.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 222 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 172.648 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 529.199 LAYER MET3 ;
  END data_i[15]
  PIN data_i[14] 
    ANTENNAPARTIALMETALAREA 187.29 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 584.415 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 415.418 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1295.19 LAYER MET3 ;
  END data_i[14]
  PIN data_i[13] 
    ANTENNAPARTIALMETALAREA 232.74 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 727.235 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 517.308 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1613.16 LAYER MET3 ;
  END data_i[13]
  PIN data_i[12] 
    ANTENNAPARTIALMETALAREA 52.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 164.465 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 242.956 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 697.564 LAYER MET3 ;
  END data_i[12]
  PIN data_i[11] 
    ANTENNAPARTIALMETALAREA 204.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 640.47 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 452.846 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1418.39 LAYER MET3 ;
  END data_i[11]
  PIN data_i[10] 
    ANTENNAPARTIALMETALAREA 250.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 774.225 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 553.725 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1712.36 LAYER MET3 ;
  END data_i[10]
  PIN data_i[9] 
    ANTENNAPARTIALMETALAREA 214.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 666.555 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 497.857 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1531.12 LAYER MET3 ;
  END data_i[9]
  PIN data_i[8] 
    ANTENNAPARTIALMETALAREA 253.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 787.915 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 563.022 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1746.52 LAYER MET3 ;
  END data_i[8]
  PIN data_i[7] 
    ANTENNAPARTIALMETALAREA 105.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 332.63 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 241.791 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 756.869 LAYER MET3 ;
  END data_i[7]
  PIN data_i[6] 
    ANTENNAPARTIALMETALAREA 296.88 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 922.41 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 656.275 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2038.04 LAYER MET3 ;
  END data_i[6]
  PIN data_i[5] 
    ANTENNAPARTIALMETALAREA 13.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.12 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 133.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 426.055 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 311.165 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 979.149 LAYER MET3 ;
  END data_i[5]
  PIN data_i[4] 
    ANTENNAPARTIALMETALAREA 122.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 382.95 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 347.066 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1010.57 LAYER MET3 ;
  END data_i[4]
  PIN data_i[3] 
    ANTENNAPARTIALMETALAREA 353.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1095.01 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 781.769 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2417.39 LAYER MET3 ;
  END data_i[3]
  PIN data_i[2] 
    ANTENNAPARTIALMETALAREA 39.72 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 84.544 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 422.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1324.6 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 945.484 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2951.93 LAYER MET3 ;
  END data_i[2]
  PIN data_i[1] 
    ANTENNAPARTIALMETALAREA 12.18 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.792 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAPARTIALMETALAREA 175.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 556.665 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 418 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 1296.88 LAYER MET3 ;
  END data_i[1]
  PIN data_i[0] 
    ANTENNAPARTIALMETALAREA 323.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1000.85 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.455 LAYER MET3 ; 
    ANTENNAMAXAREACAR 717.747 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 2218.17 LAYER MET3 ;
  END data_i[0]
  PIN instructionAddress[31] 
    ANTENNAPARTIALMETALAREA 14.22 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.144 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 61.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 197.395 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 26.4694 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 83.9237 LAYER MET3 ;
  END instructionAddress[31]
  PIN instructionAddress[30] 
    ANTENNAPARTIALMETALAREA 41.76 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 88.896 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 28.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 91.76 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 20.3878 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 57.1518 LAYER MET3 ;
  END instructionAddress[30]
  PIN instructionAddress[29] 
    ANTENNAPARTIALMETALAREA 49.46 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 105.92 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 129 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 402.93 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.71 LAYER MET3 ; 
    ANTENNAMAXAREACAR 55.1995 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 152.581 LAYER MET3 ;
  END instructionAddress[29]
  PIN instructionAddress[28] 
    ANTENNAPARTIALMETALAREA 22.02 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 107 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 335.96 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 54.1347 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 159.838 LAYER MET3 ;
  END instructionAddress[28]
  PIN instructionAddress[27] 
    ANTENNAPARTIALMETALAREA 45.56 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 97.6 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 126.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 395.9 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 78.3143 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 218.993 LAYER MET3 ;
  END instructionAddress[27]
  PIN instructionAddress[26] 
    ANTENNAPARTIALMETALAREA 33 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 70.208 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 78.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 249.195 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 44.0776 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 127.715 LAYER MET3 ;
  END instructionAddress[26]
  PIN instructionAddress[25] 
    ANTENNAPARTIALMETALAREA 8.76 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.496 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 124.96 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 397.38 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.3925 LAYER MET3 ; 
    ANTENNAMAXAREACAR 41.8485 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 119.448 LAYER MET3 ;
  END instructionAddress[25]
  PIN instructionAddress[24] 
    ANTENNAPARTIALMETALAREA 22.02 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 215.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 679.32 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 88.4327 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 279.191 LAYER MET3 ;
  END instructionAddress[24]
  PIN instructionAddress[23] 
    ANTENNAPARTIALMETALAREA 62.88 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 134.464 LAYER MET2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET2 ; 
    ANTENNAMAXAREACAR 25.9959 LAYER MET2 ;
    ANTENNAMAXSIDEAREACAR 55.8604 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNAMAXCUTCAR 0.204082 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 12.48 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.07 LAYER MET3 ;
    ANTENNAGATEAREA 4.3925 LAYER MET3 ; 
    ANTENNAMAXAREACAR 28.8371 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 65.2104 LAYER MET3 ;
  END instructionAddress[23]
  PIN instructionAddress[22] 
    ANTENNAPARTIALMETALAREA 10.32 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.824 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 47.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 152.07 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.3925 LAYER MET3 ; 
    ANTENNAMAXAREACAR 17.5819 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 50.6984 LAYER MET3 ;
  END instructionAddress[22]
  PIN instructionAddress[21] 
    ANTENNAPARTIALMETALAREA 50.9 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 108.992 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 71.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 224.59 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.3925 LAYER MET3 ; 
    ANTENNAMAXAREACAR 39.7759 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 101.818 LAYER MET3 ;
  END instructionAddress[21]
  PIN instructionAddress[20] 
    ANTENNAPARTIALMETALAREA 54.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 115.904 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 65.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 207.57 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 6.8425 LAYER MET3 ; 
    ANTENNAMAXAREACAR 33.3777 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 81.6476 LAYER MET3 ;
  END instructionAddress[20]
  PIN instructionAddress[19] 
    ANTENNAPARTIALMETALAREA 74.88 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 159.552 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 65.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 206.46 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.3925 LAYER MET3 ; 
    ANTENNAMAXAREACAR 23.3637 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 65.5343 LAYER MET3 ;
  END instructionAddress[19]
  PIN instructionAddress[18] 
    ANTENNAPARTIALMETALAREA 7.2 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.168 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 81.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 255.485 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 47.3265 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 134.984 LAYER MET3 ;
  END instructionAddress[18]
  PIN instructionAddress[17] 
    ANTENNAPARTIALMETALAREA 54.08 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 115.776 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 23.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 74 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 66.7796 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 152.651 LAYER MET3 ;
  END instructionAddress[17]
  PIN instructionAddress[16] 
    ANTENNAPARTIALMETALAREA 59.1 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 125.888 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 102.02 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 320.605 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.215 LAYER MET3 ; 
    ANTENNAMAXAREACAR 30.6118 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 85.4424 LAYER MET3 ;
  END instructionAddress[16]
  PIN instructionAddress[15] 
    ANTENNAPARTIALMETALAREA 35.3 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 75.712 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 62.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 198.69 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 29.5143 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 89.8857 LAYER MET3 ;
  END instructionAddress[15]
  PIN instructionAddress[14] 
    ANTENNAPARTIALMETALAREA 1.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.52 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 208.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 655.455 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.215 LAYER MET3 ; 
    ANTENNAMAXAREACAR 41.7805 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 129.862 LAYER MET3 ;
  END instructionAddress[14]
  PIN instructionAddress[13] 
    ANTENNAPARTIALMETALAREA 51.72 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 110.144 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 36.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 113.96 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 16.4286 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 50.5478 LAYER MET3 ;
  END instructionAddress[13]
  PIN instructionAddress[12] 
    ANTENNAPARTIALMETALAREA 39.98 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 85.696 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 46.5 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 148.555 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 29.7469 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 83.9988 LAYER MET3 ;
  END instructionAddress[12]
  PIN instructionAddress[11] 
    ANTENNAPARTIALMETALAREA 50.24 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 107.584 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 59.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 187.035 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.215 LAYER MET3 ; 
    ANTENNAMAXAREACAR 53.4736 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 126.337 LAYER MET3 ;
  END instructionAddress[11]
  PIN instructionAddress[10] 
    ANTENNAPARTIALMETALAREA 29.1 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 61.888 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 67.96 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 214.6 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.215 LAYER MET3 ; 
    ANTENNAMAXAREACAR 26.3337 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 69.922 LAYER MET3 ;
  END instructionAddress[10]
  PIN instructionAddress[9] 
    ANTENNAPARTIALMETALAREA 11.88 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.152 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 129.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 408.85 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 58.4367 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 179.192 LAYER MET3 ;
  END instructionAddress[9]
  PIN instructionAddress[8] 
    ANTENNAPARTIALMETALAREA 25.16 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 54.08 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 88.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 281.2 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.215 LAYER MET3 ; 
    ANTENNAMAXAREACAR 19.0456 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 58.7915 LAYER MET3 ;
  END instructionAddress[8]
  PIN instructionAddress[7] 
    ANTENNAPARTIALMETALAREA 101.82 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 217.024 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 81.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 254.375 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 49.6122 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 139.442 LAYER MET3 ;
  END instructionAddress[7]
  PIN instructionAddress[6] 
    ANTENNAPARTIALMETALAREA 5.64 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.84 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 43.42 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 135.605 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.45 LAYER MET3 ; 
    ANTENNAMAXAREACAR 91.1224 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 212.329 LAYER MET3 ;
  END instructionAddress[6]
  PIN instructionAddress[5] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 246.295 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 525.472 LAYER MET2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 8.295 LAYER MET2 ; 
    ANTENNAMAXAREACAR 30.3683 LAYER MET2 ;
    ANTENNAMAXSIDEAREACAR 65.0797 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.5 LAYER VIA2 ;
    ANTENNAMAXCUTCAR 0.150693 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 257.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 795.87 LAYER MET3 ;
    ANTENNAGATEAREA 22.1025 LAYER MET3 ; 
    ANTENNAMAXAREACAR 41.9977 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 101.088 LAYER MET3 ;
  END instructionAddress[5]
  PIN instructionAddress[4] 
    ANTENNAPARTIALMETALAREA 185.46 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 395.456 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 263.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 816.405 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 25.1125 LAYER MET3 ; 
    ANTENNAMAXAREACAR 47.7531 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 112.632 LAYER MET3 ;
  END instructionAddress[4]
  PIN instructionAddress[3] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 33.78 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 72.576 LAYER MET2 ;
  END instructionAddress[3]
  PIN instructionAddress[2] 
    ANTENNAPARTIALMETALAREA 61.04 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 130.624 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 271.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 851.37 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 35.9275 LAYER MET3 ; 
    ANTENNAMAXAREACAR 26.1424 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 64.3276 LAYER MET3 ;
  END instructionAddress[2]
  PIN instructionAddress[1] 
    ANTENNAPARTIALMETALAREA 15.78 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.472 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 305 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 959.78 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 17.5525 LAYER MET3 ; 
    ANTENNAMAXAREACAR 24.4424 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 71.0256 LAYER MET3 ;
  END instructionAddress[1]
  PIN instructionAddress[0] 
    ANTENNAPARTIALMETALAREA 46.22 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 99.008 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 265.92 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 836.94 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 18.2963 LAYER MET3 ; 
    ANTENNAMAXAREACAR 20.2882 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 58.4375 LAYER MET3 ;
  END instructionAddress[0]
  PIN dataAddress[63] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 503.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1565.1 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 67.0816 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 180.487 LAYER MET3 ;
  END dataAddress[63]
  PIN dataAddress[62] 
    ANTENNAPARTIALMETALAREA 131.28 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 279.872 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 19.5 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 62.715 LAYER MET3 ;
  END dataAddress[62]
  PIN dataAddress[61] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 381.96 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1187.7 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 14.6212 LAYER MET3 ; 
    ANTENNAMAXAREACAR 37.5926 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 106.088 LAYER MET3 ;
  END dataAddress[61]
  PIN dataAddress[60] 
    ANTENNAPARTIALMETALAREA 91.16 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 194.88 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 121.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 380.915 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 143.058 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 439.788 LAYER MET3 ;
  END dataAddress[60]
  PIN dataAddress[59] 
    ANTENNAPARTIALMETALAREA 35.66 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 76.48 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 134.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 424.575 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 149.618 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 472.715 LAYER MET3 ;
  END dataAddress[59]
  PIN dataAddress[58] 
    ANTENNAPARTIALMETALAREA 37.2 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 79.168 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 76.6 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 241.24 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 88.3324 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 275.116 LAYER MET3 ;
  END dataAddress[58]
  PIN dataAddress[57] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 819.14 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 2534.68 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 75.2994 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 218.476 LAYER MET3 ;
  END dataAddress[57]
  PIN dataAddress[56] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 431.68 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1335.7 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 23.8612 LAYER MET3 ; 
    ANTENNAMAXAREACAR 23.9621 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 69.6522 LAYER MET3 ;
  END dataAddress[56]
  PIN dataAddress[55] 
    ANTENNAPARTIALMETALAREA 14.52 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 91.52 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 288.23 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 122.332 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 364.099 LAYER MET3 ;
  END dataAddress[55]
  PIN dataAddress[54] 
    ANTENNAPARTIALMETALAREA 54.48 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 116.032 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 72.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 228.845 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 81.706 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 257.627 LAYER MET3 ;
  END dataAddress[54]
  PIN dataAddress[53] 
    ANTENNAPARTIALMETALAREA 20.76 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 44.096 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 233.6 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 734.82 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 11.2788 LAYER MET3 ; 
    ANTENNAMAXAREACAR 48.5384 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 125.454 LAYER MET3 ;
  END dataAddress[53]
  PIN dataAddress[52] 
    ANTENNAPARTIALMETALAREA 10.68 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.592 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 325.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1011.58 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 9.79125 LAYER MET3 ; 
    ANTENNAMAXAREACAR 47.1404 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 133.939 LAYER MET3 ;
  END dataAddress[52]
  PIN dataAddress[51] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 465.24 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1447.07 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.8987 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.5292 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 105.325 LAYER MET3 ;
  END dataAddress[51]
  PIN dataAddress[50] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 398.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1233.77 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 14.6825 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.8302 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 102.962 LAYER MET3 ;
  END dataAddress[50]
  PIN dataAddress[49] 
    ANTENNAPARTIALMETALAREA 2.82 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.824 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 106.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 337.44 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 147.585 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 436.602 LAYER MET3 ;
  END dataAddress[49]
  PIN dataAddress[48] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 446.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1383.99 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.5663 LAYER MET3 ; 
    ANTENNAMAXAREACAR 55.2445 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 146.95 LAYER MET3 ;
  END dataAddress[48]
  PIN dataAddress[47] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 366.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1132.94 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.4225 LAYER MET3 ; 
    ANTENNAMAXAREACAR 32.7592 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 97.1725 LAYER MET3 ;
  END dataAddress[47]
  PIN dataAddress[46] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 289.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 893.92 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.275 LAYER MET3 ; 
    ANTENNAMAXAREACAR 131.366 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 402.61 LAYER MET3 ;
  END dataAddress[46]
  PIN dataAddress[45] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 420.24 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1301.29 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 16.8263 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.1979 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 99.3845 LAYER MET3 ;
  END dataAddress[45]
  PIN dataAddress[44] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 416.88 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1293.52 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 14.6825 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.9781 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 105.431 LAYER MET3 ;
  END dataAddress[44]
  PIN dataAddress[43] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 528.3 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1636.33 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 23.8613 LAYER MET3 ; 
    ANTENNAMAXAREACAR 75.0883 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 182.471 LAYER MET3 ;
  END dataAddress[43]
  PIN dataAddress[42] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 414.56 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1286.49 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 16.5638 LAYER MET3 ; 
    ANTENNAMAXAREACAR 33.0089 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 95.6336 LAYER MET3 ;
  END dataAddress[42]
  PIN dataAddress[41] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 480.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1498.69 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 20.9125 LAYER MET3 ; 
    ANTENNAMAXAREACAR 28.7878 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 84.3888 LAYER MET3 ;
  END dataAddress[41]
  PIN dataAddress[40] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 433.8 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1347.54 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 37.9003 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 111.829 LAYER MET3 ;
  END dataAddress[40]
  PIN dataAddress[39] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 467.5 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1448 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 16.8263 LAYER MET3 ; 
    ANTENNAMAXAREACAR 39.534 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 113.022 LAYER MET3 ;
  END dataAddress[39]
  PIN dataAddress[38] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 350.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1080.77 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.33 LAYER MET3 ; 
    ANTENNAMAXAREACAR 287.105 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 866.21 LAYER MET3 ;
  END dataAddress[38]
  PIN dataAddress[37] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 332.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1027.3 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.33 LAYER MET3 ; 
    ANTENNAMAXAREACAR 292.353 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 865.02 LAYER MET3 ;
  END dataAddress[37]
  PIN dataAddress[36] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 432.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1340.7 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 39.9 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 116.63 LAYER MET3 ;
  END dataAddress[36]
  PIN dataAddress[35] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 519 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1622.45 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 19.075 LAYER MET3 ; 
    ANTENNAMAXAREACAR 38.9986 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 111.291 LAYER MET3 ;
  END dataAddress[35]
  PIN dataAddress[34] 
    ANTENNAPARTIALMETALAREA 14.52 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 78.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 248.64 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 122.277 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 351.89 LAYER MET3 ;
  END dataAddress[34]
  PIN dataAddress[33] 
    ANTENNAPARTIALMETALAREA 93.42 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 199.104 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 325.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1017.68 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 12.5563 LAYER MET3 ; 
    ANTENNAMAXAREACAR 99.1108 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 238.197 LAYER MET3 ;
  END dataAddress[33]
  PIN dataAddress[32] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 534.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1653.16 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 12.0225 LAYER MET3 ; 
    ANTENNAMAXAREACAR 52.9123 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 156.666 LAYER MET3 ;
  END dataAddress[32]
  PIN dataAddress[31] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 534.9 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1658.15 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 11.2788 LAYER MET3 ; 
    ANTENNAMAXAREACAR 57.0546 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 168.708 LAYER MET3 ;
  END dataAddress[31]
  PIN dataAddress[30] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 450.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1399.53 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 48.4478 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 136.239 LAYER MET3 ;
  END dataAddress[30]
  PIN dataAddress[29] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 500.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1552.15 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 12.4775 LAYER MET3 ; 
    ANTENNAMAXAREACAR 47.221 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 140.885 LAYER MET3 ;
  END dataAddress[29]
  PIN dataAddress[28] 
    ANTENNAPARTIALMETALAREA 18.42 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.104 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 54.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 174.455 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 79.6291 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 235.133 LAYER MET3 ;
  END dataAddress[28]
  PIN dataAddress[27] 
    ANTENNAPARTIALMETALAREA 42.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 91.584 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 171.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 534.28 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 190.299 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 593.27 LAYER MET3 ;
  END dataAddress[27]
  PIN dataAddress[26] 
    ANTENNAPARTIALMETALAREA 53.6 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 114.752 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 36.38 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 118.215 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 46.0027 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 143.792 LAYER MET3 ;
  END dataAddress[26]
  PIN dataAddress[25] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 736.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 2282.72 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.8987 LAYER MET3 ; 
    ANTENNAMAXAREACAR 49.6672 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 151.76 LAYER MET3 ;
  END dataAddress[25]
  PIN dataAddress[24] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 446.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1379.36 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 14.6825 LAYER MET3 ; 
    ANTENNAMAXAREACAR 39.7057 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 114.935 LAYER MET3 ;
  END dataAddress[24]
  PIN dataAddress[23] 
    ANTENNAPARTIALMETALAREA 50.64 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 107.84 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 26.6 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 85.47 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 64.706 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 170.543 LAYER MET3 ;
  END dataAddress[23]
  PIN dataAddress[22] 
    ANTENNAPARTIALMETALAREA 72.36 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 154.176 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 10 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.56 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 186.86 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 412.004 LAYER MET3 ;
  END dataAddress[22]
  PIN dataAddress[21] 
    ANTENNAPARTIALMETALAREA 23.16 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 49.216 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 11.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 37 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.91 LAYER MET3 ; 
    ANTENNAMAXAREACAR 62.6181 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 148.365 LAYER MET3 ;
  END dataAddress[21]
  PIN dataAddress[20] 
    ANTENNAPARTIALMETALAREA 48.92 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 104.768 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 191.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 606.985 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 21.2625 LAYER MET3 ; 
    ANTENNAMAXAREACAR 13.482 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 38.5645 LAYER MET3 ;
  END dataAddress[20]
  PIN dataAddress[19] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 413.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1284.64 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 39.5343 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 114.805 LAYER MET3 ;
  END dataAddress[19]
  PIN dataAddress[18] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 489.72 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1515.52 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.4225 LAYER MET3 ; 
    ANTENNAMAXAREACAR 42.7649 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 126.715 LAYER MET3 ;
  END dataAddress[18]
  PIN dataAddress[17] 
    ANTENNAPARTIALMETALAREA 23.16 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 49.216 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 182.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 574.61 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.23 LAYER MET3 ; 
    ANTENNAMAXAREACAR 21.3629 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 60.7639 LAYER MET3 ;
  END dataAddress[17]
  PIN dataAddress[16] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 609.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1889.04 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.5663 LAYER MET3 ; 
    ANTENNAMAXAREACAR 47.7474 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 140.796 LAYER MET3 ;
  END dataAddress[16]
  PIN dataAddress[15] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 373.46 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1158.29 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 83.3294 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 204.995 LAYER MET3 ;
  END dataAddress[15]
  PIN dataAddress[14] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 406.02 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1257.44 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 18.7075 LAYER MET3 ; 
    ANTENNAMAXAREACAR 27.5745 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 80.8905 LAYER MET3 ;
  END dataAddress[14]
  PIN dataAddress[13] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 378.3 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1173.83 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.5663 LAYER MET3 ; 
    ANTENNAMAXAREACAR 49.0526 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 130.015 LAYER MET3 ;
  END dataAddress[13]
  PIN dataAddress[12] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 450.48 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1396.38 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 57.8519 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 157.531 LAYER MET3 ;
  END dataAddress[12]
  PIN dataAddress[11] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 656 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 2032.78 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 23.8612 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.9346 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 104.352 LAYER MET3 ;
  END dataAddress[11]
  PIN dataAddress[10] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 461.24 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1432.64 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 21.7175 LAYER MET3 ; 
    ANTENNAMAXAREACAR 25.3618 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 76.5009 LAYER MET3 ;
  END dataAddress[10]
  PIN dataAddress[9] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 495.4 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1535.5 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 16.8875 LAYER MET3 ; 
    ANTENNAMAXAREACAR 34.8478 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 103.311 LAYER MET3 ;
  END dataAddress[9]
  PIN dataAddress[8] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 410.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1276.69 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 20.8513 LAYER MET3 ; 
    ANTENNAMAXAREACAR 23.1482 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 68.9524 LAYER MET3 ;
  END dataAddress[8]
  PIN dataAddress[7] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 429.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1331.26 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.8163 LAYER MET3 ; 
    ANTENNAMAXAREACAR 36.9679 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 109.299 LAYER MET3 ;
  END dataAddress[7]
  PIN dataAddress[6] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 416.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1288.71 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 11.1562 LAYER MET3 ; 
    ANTENNAMAXAREACAR 45.4585 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 133.761 LAYER MET3 ;
  END dataAddress[6]
  PIN dataAddress[5] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 476.48 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1472.23 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 15.4438 LAYER MET3 ; 
    ANTENNAMAXAREACAR 35.9323 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 107.315 LAYER MET3 ;
  END dataAddress[5]
  PIN dataAddress[4] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 403.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1253.38 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 13.755 LAYER MET3 ; 
    ANTENNAMAXAREACAR 67.6139 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 174.422 LAYER MET3 ;
  END dataAddress[4]
  PIN dataAddress[3] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 460.34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1426.9 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.8275 LAYER MET3 ; 
    ANTENNAMAXAREACAR 92.1318 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 274.297 LAYER MET3 ;
  END dataAddress[3]
  PIN dataAddress[2] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 641.24 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1988.01 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 9.79125 LAYER MET3 ; 
    ANTENNAMAXAREACAR 69.8253 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 213.242 LAYER MET3 ;
  END dataAddress[2]
  PIN dataAddress[1] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 461.76 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1440.78 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 9.79125 LAYER MET3 ; 
    ANTENNAMAXAREACAR 66.2511 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 188.815 LAYER MET3 ;
  END dataAddress[1]
  PIN dataAddress[0] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 626.6 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 1942.13 LAYER MET3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 21.7175 LAYER MET3 ; 
    ANTENNAMAXAREACAR 36.8688 LAYER MET3 ;
    ANTENNAMAXSIDEAREACAR 107.059 LAYER MET3 ;
  END dataAddress[0]
  PIN data_o[63] 
    ANTENNAPARTIALMETALAREA 28.56 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 60.736 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 43.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 139.305 LAYER MET3 ;
  END data_o[63]
  PIN data_o[62] 
    ANTENNAPARTIALMETALAREA 3.6 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.488 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 10.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.82 LAYER MET3 ;
  END data_o[62]
  PIN data_o[61] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 188.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 582.195 LAYER MET3 ;
  END data_o[61]
  PIN data_o[60] 
    ANTENNAPARTIALMETALAREA 22.32 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.424 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 118.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 370 LAYER MET3 ;
  END data_o[60]
  PIN data_o[59] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 24.58 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 52.352 LAYER MET2 ;
  END data_o[59]
  PIN data_o[58] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 59.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 126.08 LAYER MET2 ;
  END data_o[58]
  PIN data_o[57] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 223.74 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 690.605 LAYER MET3 ;
  END data_o[57]
  PIN data_o[56] 
    ANTENNAPARTIALMETALAREA 27.84 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 59.2 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 54.04 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 170.94 LAYER MET3 ;
  END data_o[56]
  PIN data_o[55] 
    ANTENNAPARTIALMETALAREA 45.78 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 97.472 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 32.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 103.23 LAYER MET3 ;
  END data_o[55]
  PIN data_o[54] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 17.62 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.504 LAYER MET2 ;
  END data_o[54]
  PIN data_o[53] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 58.3 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 124.288 LAYER MET2 ;
  END data_o[53]
  PIN data_o[52] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 23.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 50.56 LAYER MET2 ;
  END data_o[52]
  PIN data_o[51] 
    ANTENNAPARTIALMETALAREA 29.52 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 62.784 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 300.2 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 931.66 LAYER MET3 ;
  END data_o[51]
  PIN data_o[50] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 179.62 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 553.705 LAYER MET3 ;
  END data_o[50]
  PIN data_o[49] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 16.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.224 LAYER MET2 ;
  END data_o[49]
  PIN data_o[48] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 177.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 547.785 LAYER MET3 ;
  END data_o[48]
  PIN data_o[47] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 184.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 569.245 LAYER MET3 ;
  END data_o[47]
  PIN data_o[46] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 177.66 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 548.525 LAYER MET3 ;
  END data_o[46]
  PIN data_o[45] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 195.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 603.655 LAYER MET3 ;
  END data_o[45]
  PIN data_o[44] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 164.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 506.345 LAYER MET3 ;
  END data_o[44]
  PIN data_o[43] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 165.06 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 509.675 LAYER MET3 ;
  END data_o[43]
  PIN data_o[42] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 300.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 925.74 LAYER MET3 ;
  END data_o[42]
  PIN data_o[41] 
    ANTENNAPARTIALMETALAREA 36.42 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 77.504 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 39.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 123.95 LAYER MET3 ;
  END data_o[41]
  PIN data_o[40] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 288.54 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 890.405 LAYER MET3 ;
  END data_o[40]
  PIN data_o[39] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 163.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 505.05 LAYER MET3 ;
  END data_o[39]
  PIN data_o[38] 
    ANTENNAPARTIALMETALAREA 17.7 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.568 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 131.7 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 413.845 LAYER MET3 ;
  END data_o[38]
  PIN data_o[37] 
    ANTENNAPARTIALMETALAREA 9.84 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 29.28 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 95.46 LAYER MET3 ;
  END data_o[37]
  PIN data_o[36] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 195.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 604.21 LAYER MET3 ;
  END data_o[36]
  PIN data_o[35] 
    ANTENNAPARTIALMETALAREA 87.3 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 186.048 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 50.26 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 159.285 LAYER MET3 ;
  END data_o[35]
  PIN data_o[34] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 47.14 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 100.48 LAYER MET2 ;
  END data_o[34]
  PIN data_o[33] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 16.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.224 LAYER MET2 ;
  END data_o[33]
  PIN data_o[32] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 16.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.224 LAYER MET2 ;
  END data_o[32]
  PIN data_o[31] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 15.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.915 LAYER MET3 ;
  END data_o[31]
  PIN data_o[30] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 33.94 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 104.525 LAYER MET3 ;
  END data_o[30]
  PIN data_o[29] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 15.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.915 LAYER MET3 ;
  END data_o[29]
  PIN data_o[28] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 19.78 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.865 LAYER MET3 ;
  END data_o[28]
  PIN data_o[27] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 173.08 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 533.54 LAYER MET3 ;
  END data_o[27]
  PIN data_o[26] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 233.44 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 719.65 LAYER MET3 ;
  END data_o[26]
  PIN data_o[25] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 37.36 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 115.07 LAYER MET3 ;
  END data_o[25]
  PIN data_o[24] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 110.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 340.03 LAYER MET3 ;
  END data_o[24]
  PIN data_o[23] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 164.96 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 510.23 LAYER MET3 ;
  END data_o[23]
  PIN data_o[22] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 186.88 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 576.09 LAYER MET3 ;
  END data_o[22]
  PIN data_o[21] 
    ANTENNAPARTIALMETALAREA 88.08 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 187.712 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 2.48 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.51 LAYER MET3 ;
  END data_o[21]
  PIN data_o[20] 
    ANTENNAPARTIALMETALAREA 71.04 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 151.36 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 4.16 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.69 LAYER MET3 ;
  END data_o[20]
  PIN data_o[19] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 15.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.915 LAYER MET3 ;
  END data_o[19]
  PIN data_o[18] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 32.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 99.53 LAYER MET3 ;
  END data_o[18]
  PIN data_o[17] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 124.9 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 266.368 LAYER MET2 ;
  END data_o[17]
  PIN data_o[16] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 15.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.915 LAYER MET3 ;
  END data_o[16]
  PIN data_o[15] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 34 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 104.71 LAYER MET3 ;
  END data_o[15]
  PIN data_o[14] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 33.94 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 104.525 LAYER MET3 ;
  END data_o[14]
  PIN data_o[13] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.24 LAYER MET3 ;
  END data_o[13]
  PIN data_o[12] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 35.68 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 109.89 LAYER MET3 ;
  END data_o[12]
  PIN data_o[11] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 18.94 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 58.275 LAYER MET3 ;
  END data_o[11]
  PIN data_o[10] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 32.32 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 99.53 LAYER MET3 ;
  END data_o[10]
  PIN data_o[9] 
    ANTENNAPARTIALMETALAREA 26.28 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 55.872 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 32.18 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 102.675 LAYER MET3 ;
  END data_o[9]
  PIN data_o[8] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 15.58 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.915 LAYER MET3 ;
  END data_o[8]
  PIN data_o[7] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 31.42 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 96.755 LAYER MET3 ;
  END data_o[7]
  PIN data_o[6] 
    ANTENNAPARTIALMETALAREA 12.18 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.792 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 49.72 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 155.03 LAYER MET3 ;
  END data_o[6]
  PIN data_o[5] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 32.38 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 99.715 LAYER MET3 ;
  END data_o[5]
  PIN data_o[4] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 18.1 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.685 LAYER MET3 ;
  END data_o[4]
  PIN data_o[3] 
    ANTENNAPARTIALMETALAREA 52.86 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 112.576 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 25.88 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 83.25 LAYER MET3 ;
  END data_o[3]
  PIN data_o[2] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 133.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 285.824 LAYER MET2 ;
  END data_o[2]
  PIN data_o[1] 
    ANTENNAPARTIALMETALAREA 51.2 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 109.632 LAYER MET2 ;
    ANTENNAPARTIALCUTAREA 0.25 LAYER VIA2 ;
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 35.64 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 115.07 LAYER MET3 ;
  END data_o[1]
  PIN data_o[0] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 14.74 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.325 LAYER MET3 ;
  END data_o[0]
  PIN MemWrite[6] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 19.32 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.728 LAYER MET2 ;
  END MemWrite[6]
  PIN MemWrite[7] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 19.5 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 42.88 LAYER MET2 ;
  END MemWrite[7]
  PIN MemWrite[5] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 21.82 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.464 LAYER MET2 ;
  END MemWrite[5]
  PIN MemWrite[4] 
    ANTENNADIFFAREA 100000 LAYER MET2 ; 
    ANTENNAPARTIALMETALAREA 16.74 LAYER MET2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.224 LAYER MET2 ;
  END MemWrite[4]
  PIN MemWrite[2] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 18.12 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.61 LAYER MET3 ;
  END MemWrite[2]
  PIN MemWrite[3] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 18.3 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 58.275 LAYER MET3 ;
  END MemWrite[3]
  PIN MemWrite[1] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 10.98 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.595 LAYER MET3 ;
  END MemWrite[1]
  PIN MemWrite[0] 
    ANTENNADIFFAREA 100000 LAYER MET3 ; 
    ANTENNAPARTIALMETALAREA 12.22 LAYER MET3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.555 LAYER MET3 ;
  END MemWrite[0]
END RISCV_superscalar

END LIBRARY
